## drivers/data-kernel/Kconfig
```kconfig
source "drivers/data-kernel/emac-dwc-eqos/Kconfig"
source "drivers/data-kernel/rmnet/Kconfig"
```
